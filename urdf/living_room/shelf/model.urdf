Commit message: Living room images are uploaded

File: urdf/living_room/shelf/model.urdf (robot description, URDF)
Before this commit: robot SquareShelf, 1 links, 0 joints
Links:
- link body: geometry collision mesh filename=meshes/wood4.obj; visual mesh filename=meshes/wood4.obj
